# Keil uVision project Template.uvproj, settings and files
target Project (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Inc
  group main
    ./: main.c
  group Hardware
    ./Src/: Delayms.c Delayus.c
